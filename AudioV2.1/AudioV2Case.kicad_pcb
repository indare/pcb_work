# Repository indare/pcb_work

File README.md:

# PCB Work

KiCad 10 の基板・回路図リポジトリです。**いま設計作業をしているのは `AudioV2/`**。
v1 の実機（AudioCase / MeasurementADC）は `Audio/` にあり、こちらは組んで動いているものです。

## ディレクトリ

| パス | 内容 |
| --- | --- |
| `AudioV2/` | 現行の設計作業。回路図・生成スクリプト・検討メモ。[案内](AudioV2/AGENT_HANDOFF.md) |
| `Audio/` | v1 実機。AudioCase 本体・MeasurementADC・分割 Gerber・計測 FW。[案内](Audio/README.md) |
| `Control/` | Controll 用 Pico2 ファーム（親／子） |
| `docker/` | KiCad 10.0.6 のヘッドレス検証環境（ERC / ネットリスト / DRC / Gerber）。[案内](docker/kicad-cloud-build/README.md) |
| `scripts/` | 環境セットアップ。ローカルで回せない検証をクラウドエージェントへ投げるための導入手順。[案内](scripts/README.md) |
| `.cursor/` | Cursor 用ルール・MCP 設定 |

## いまの実機（要約）

- **Amp → MeasurementADC（LCD スペアナ）** が接続して動作中
- Controll 2 段は外している。EQ は今号では使わない
- 次は MeasurementADC 初号ジャンパの次号解消 → 端子台／ケース
- 詳細: [Audio/MeasurementADC_STATUS.md](Audio/MeasurementADC_STATUS.md)

## Cursor MCP（KiCad）

プロジェクト設定: [`.cursor/mcp.json`](.cursor/mcp.json)  
雛形: [`.cursor/mcp.json.example`](.cursor/mcp.json.example)

個人の絶対パスはコミットしません。Cursor の変数展開を使います。
**2026-09-04 に Cursor で実際に動作確認済み**（`${workspaceFolder}` は展開され、`uvx` は PATH から解決される）。

```json
{
  "mcpServers": {
    "kicad": {
      "type": "stdio",
      "command": "uvx",
      "args": ["kicad-mcp-pro"],
      "env": {
        "KICAD_MCP_PROJECT_DIR": "${workspaceFolder}/AudioV2",
        "KICAD_MCP_PROFILE": "full",
        "KICAD_MCP_OPERATING_MODE": "write"
      }
    }
  }
}
```

### 前提

1. [uv](https://docs.astral.sh/uv/) を入れる（`uvx` が PATH に載ること）
2. Cursor を再起動し、**Settings → Tools & MCP** で `kicad` を ON
3. KiCad で基板を開くときは IPC API を有効にしておく（MCP のライブ連携用）

### 変数

| 値 | 意味 |
| --- | --- |
| `${workspaceFolder}` | このリポジトリのルート（`.cursor/mcp.json` がある側） |
| `KICAD_MCP_PROJECT_DIR` | KiCad プロジェクトディレクトリ（現行は `AudioV2/`） |
| `KICAD_MCP_PROFILE` | `full`（2026-09-02 に `build` から変更。AudioV2 移行と同時） |
| `KICAD_MCP_OPERATING_MODE` | `write`（読み取り専用にしたい場合は `readonly`） |

### PATH に `uvx` が無い場合

ユーザー設定 `~/.cursor/mcp.json`（コミット対象外）にだけフルパスを書いてください。  
ローカル上書き用: `.cursor/mcp.local.env`（gitignore 済み）。

### Windows / Git Bash

このリポジトリの KiCad CLI は Git Bash 経由を想定しています。`kicad-cli` は KiCad 10.0 の bin が PATH にあること。

## MeasurementADC メモ

- 進捗: `Audio/MeasurementADC_STATUS.md`
- 発注: `Audio/MeasurementADC_ORDER.md`
- ブリングアップ履歴: `Audio/MeasurementADC_BRINGUP.md`
- MBC2596-01 FP（0°）: 左上 IN+ / 左下 IN- / 右上 OUT+ / 右下 OUT-

## KiCad design AudioV2.1/AudioV2Case.kicad_pcb

File AudioV2.1/README.md:

# AudioV2.1

**「オペアンプを電子的に切り替えて、なんとなく音が違うのを楽しむ箱」の KiCad プロジェクト。**
計測系が載っているのは表示と簡易分析のためで、装置そのものは計測器ではない。優劣は測定ではなく耳で決める。

v2.1 は「選んだ ch だけ電源と入力を生かす」構成。何を決めたかは [DECISIONS.md](DECISIONS.md)、いま何待ちかは [NOW.md](NOW.md)。
この段落より詳しいことは以下の文書が正。**README には書かない。**

## 入口

| | 何が書いてあるか |
|---|---|
| [NOW.md](NOW.md) | **いま何待ちか・次の一手。再開はここから** |
| [CLAUDE.md](CLAUDE.md) | 守ること。シートの所有権・禁止事項・検証コマンドと期待値 |
| [DECISIONS.md](DECISIONS.md) | **決定の正。** 何を決めたか・なぜか・何を捨てたか。v2 から引き継いだものは §7 |

## この下にあるもの

| | |
|---|---|
| `*.kicad_sch` / `AudioV2.kicad_sym` / `AudioV2Case.kicad_pro` / `AudioV2Case.kicad_pcb` | 回路図と PCB |
| [lib/](lib/) | プロジェクトの KiCad ライブラリ（`Library.pretty`・`BP5293_ROHM`・`MeasurementADC1804`・`MeasurementADC_Extras`）。名前は図の `lib_id` と PCB の footprint 名が使うので変えない |
| [ds_facts/](ds_facts/) | データシートから読んだ事実（照合済み） |
| [datasheets/](datasheets/README.md) | 参照したデータシート PDF。手持ちオペアンプの DS は `datasheets/opamps/` |
| [OPAMP_STOCK.md](OPAMP_STOCK.md) | 手持ちオペアンプの一覧（ユーザー申告） |
| [PARTS.md](PARTS.md) | 品番と機能等価の代替。BOM のブロックは回路図から生成する |
| [review/](review/README.md) | 調査・否定側査読・棚卸しの記録（凍結。行番号の基準は `review/README.md`） |
| [spice/](spice/README.md) | 設計判断の根拠に回した ngspice ネットリスト |
| [scripts/](scripts/) | 回路図の生成・編集・検証の道具（v2 からの写し。扱いは [CLAUDE.md](CLAUDE.md)） |
| [firmware/](firmware/README.md) | Pico のファーム（骨格） |
| [legacy/](legacy/README.md) | 道具が読む旧シート（v2 からの写し。設計には反映されない） |
| 発注リスト | **持たない。** 発注のときに [PARTS.md](PARTS.md) の生成部品表から起こす。ベンダのデータを読むときの罠は §0b |

部品数・ERC 件数・ネット名・ピン接続は**回路図が正**。文書の値は当時のもの。

Parts:
C201, C205, C207: 47u; CP_Radial_D8.0mm_P3.50mm
C202, C204, C206, C208, C402: 0.1u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C203: 10u; CP_Radial_D5.0mm_P2.00mm
C401: 22u; CP_Radial_D6.3mm_P2.50mm
C403, C404, C410, C411: 100n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C405, C406, C407, C409: 2.2u; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C408, C412: 2.7n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C501, C502: 470uF 25V NP; CP_Radial_D16.0mm_P7.50mm
C503, C504: 10uF 25V X7R; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C505, C506: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
F201: F2A fast 5x20; Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Op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
F202: PPTC 0.4A hold; PPTC_Radial_D7.9mm_T3.1mm_P5.08mm
F203: PPTC 0.1A hold; PPTC_Radial_D7.9mm_T3.1mm_P5.08mm
J201: +15/A_GND/-15 out; TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizont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
J202: PD module in (1=GND 2=+12V); TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J_ANA101: SLOT1 ANA (D18); PinSocket_2x05_P2.54mm_Vertical
J_HP501: HP OUT; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J_IN401: AUDIO IN L/R; TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizont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
J_LINE501: LINE OUT; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J_PNL1601_1: FrontPanel digital A (odd); JST_XH_B10B-XH-A_1x10_P2.50mm_Vertical
J_PNL1601_2: FrontPanel digital B (even); JST_XH_B10B-XH-A_1x10_P2.50mm_Vertical
J_PNL_A1601_1: FrontPanel analog A (odd); JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J_PNL_A1601_2: FrontPanel analog B (even); JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J_PNL_P1601: FrontPanel 12V raw; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J_PNL_P1602: FrontPanel 12V switched; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J_PWR101: SLOT1 PWR/CTRL (D18); PinSocket_2x08_P2.54mm_Vertical
J_RAIL501: AMP_SEL OUT; TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizont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
NT101: GND_COIL-D_GND; NetTie-2_SMD_Pad2.0mm
Q401, Q402: BSS138; SOT-23
R410, R411: 5.6k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R412, R413: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R501, R502: 10R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R503, R504: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U201: REC20K-2415DZ; REC20K-Z_1in_THT; MPN REC20K-2415DZ
U202: L7809CV +9V; TO-220-3_Vertical
U402: PT2314E; SOIC-28W_7.5x17.9mm_P1.27mm
U403: BP5293-50 +5V; BP5293-50_ROHM_SIP-3
U501: OPA1652; DIP-8_W7.62mm_Socket

Connections:
/3V3: J_PNL1601_1.1, J_PWR101.10, Q401.1 (G), Q402.1 (G); also elsewhere on the board
/+5V_COIL: J_PWR101.5, U403.3 (VOUT); also elsewhere on the board
/+5V_D: J_PNL1601_2.1; also elsewhere on the board
/+15V: C201.1, C202.1, C503.1, C505.1, F203.1, J201.1, J_PWR101.1, U201.6 (+Vout), U501.8 (V+); also elsewhere on the board
/-15V: C207.2, C208.2, C504.2, C506.2, J201.3, J_PWR101.3, U201.4 (-Vout), U501.4 (V-); also elsewhere on the board
/AMP_SEL_L: J_ANA101.7, J_PNL_A1601_1.1, J_RAIL501.1; also elsewhere on the board
/AMP_SEL_R: J_ANA101.10, J_PNL_A1601_2.1, J_RAIL501.3; also elsewhere on the board
/A_GND: C201.2, C202.2, C203.2, C204.2, C207.1, C208.1, C401.2, C402.2, C408.2, C412.2, C503.2, C504.1, C505.2, C506.1, J201.2, J_ANA101.1, J_ANA101.2, J_ANA101.4, J_ANA101.5, J_ANA101.8, J_ANA101.9, J_HP501.2, J_IN401.2, J_LINE501.2, J_PNL_A1601_1.4, J_PNL_A1601_2.4, J_PWR101.2, J_PWR101.4, J_RAIL501.2, R410.2, R411.2, R503.2, R504.2, U201.5 (COM), U202.2 (GND), U402.2 (AGND), U402.25 (DGND); also elsewhere on the board
/COMMON_L: C406.1, J_IN401.1
/COMMON_R: C407.1, J_IN401.3
/D_GND: J_PNL1601_1.2, J_PNL1601_2.2, J_PWR101.8, NT101.2; also elsewhere on the board
/ENC_INTA: J_PNL1601_1.4; also elsewhere on the board
/ENC_INTB: J_PNL1601_2.4; also elsewhere on the board
/GND_COIL: J_PWR101.6, NT101.1, U403.2 (GND); also elsewhere on the board
/HP_OUT_L: R501.1, U501.1, U501.2 (-)
/HP_OUT_R: R502.1, U501.6 (-), U501.7
/HP_RC_L: C501.1, R501.2
/HP_RC_R: C502.1, R502.2
/I2C_SCL: J_PNL1601_2.3, J_PWR101.9, Q402.2 (S); also elsewhere on the board
/I2C_SCL_9V: Q402.3 (D), R413.2, U402.27 (CLK)
/I2C_SDA: J_PNL1601_1.3, J_PWR101.7, Q401.2 (S); also elsewhere on the board
/I2C_SDA_9V: Q401.3 (D), R412.2, U402.26 (DATA)
/LCD_CS: J_PNL1601_1.5; also elsewhere on the board
/LCD_DC: J_PNL1601_2.5; also elsewhere on the board
/LCD_EN: J_PNL1601_2.6; also elsewhere on the board
/LCD_MOSI: J_PNL1601_2.7; also elsewhere on the board
/LCD_RST: J_PNL1601_1.6; also elsewhere on the board
/LCD_SCK: J_PNL1601_1.7; also elsewhere on the board
/LINE_L: J_LINE501.1, J_PNL_A1601_1.3; also elsewhere on the board
/LINE_R: J_LINE501.3, J_PNL_A1601_2.3; also elsewhere on the board
/PD_12V: J202.2, J_PNL_P1601.1; also elsewhere on the board
/PD_12V_COIL: F202.2, U403.1 (VIN)
/PD_12V_SW: F201.1, F202.1, J_PNL_P1602.1; also elsewhere on the board
/PD_GND: C205.1, C206.1, J202.1, J_PNL_P1601.2, J_PNL_P1602.2, U201.2 (-Vin); also elsewhere on the board
/PHONE_BUF_L: J_PNL_A1601_1.2, U501.3 (+); also elsewhere on the board
/PHONE_BUF_R: J_PNL_A1601_2.2, U501.5 (+); also elsewhere on the board
/PHONE_L: C501.2, J_HP501.1, R503.1
/PHONE_R: C502.2, J_HP501.3, R504.1
/PT_BASS_L: C403.2, C410.2, R410.1
/PT_BASS_R: C404.2, C411.2, R411.1
/PT_BIN_L: C410.1, U402.19 (BIN_L)
/PT_BIN_R: C411.1, U402.21 (BIN_R)
/PT_BOUT_L: C403.1, U402.20 (BOUT_L)
/PT_BOUT_R: C404.1, U402.22 (BOUT_R)
/PT_LIN: C406.2, U402.17 (LIN)
/PT_OUT_L: C405.1, U402.24 (OUT_L)
/PT_OUT_R: C409.1, U402.23 (OUT_R)
/PT_REF: C401.1, U402.28 (REF)
/PT_RIN: C407.2, U402.5 (RIN)
/PT_TREB_L: C408.1, U402.3 (TREB_L)
/PT_TREB_R: C412.1, U402.4 (TREB_R)
/TONE_L: C405.2, J_ANA101.3; also elsewhere on the board
/TONE_R: C409.2, J_ANA101.6; also elsewhere on the board
/TP_INT: J_PNL1601_1.9; also elsewhere on the board
/TP_RST: J_PNL1601_2.9; also elsewhere on the board
/TP_SCL: J_PNL1601_2.8; also elsewhere on the board
/TP_SDA: J_PNL1601_1.8; also elsewhere on the board
/VCC_TONE: C203.1, C204.1, C402.1, R412.1, R413.1, U202.3 (VO), U402.1 (VDD)
unnamed: C205.2, C206.2, F201.2, U201.1 (+Vin)
unnamed: F203.2, U202.1 (VI)

Notes on the sheet:
HP バッファ（2026-09-08、v1 HeadphoneBufferModule を 5xx で移設）: RV501 ワイパー → PHONE_BUF_L/R → U501 ユニティ → 10Ω → 470µF NP → PHONE_L/R → J_HP501 / 親。100k はジャック側のブリード。U501 は DIP-8 ソケット、標準実装 OPA1652。LINE はバッファ無し（RV502 直出し）のまま。配線はピン先ラベル（このシートの流儀）。
AudioV2 PowerModule — label-wired (§9 / CIRCUIT_DESIGN §4) PD module in → PD_12V → panel SW → PD_12V_SW → fuse → DC-DC +Vin Primary PD_GND ≠ secondary A_GND. DC-DC CTRL left unconnected (open = ON). LM7809 GND→A_GND. Connectivity = local labels on pin tips (same name = same net).
ControlPanelAnalog — tone / DEST / PWR（UI は MeasureControl へ移設済み） PT2314E / SW402 PWR / D403 パネル LED / BP5293-50(+5V_COIL) / DEST 機械 SW ENC×3・DEST LED・I²C マスタは FrontPanel/MeasureControl（MCP23017 0x22 → ENC_INTA/B）。状態表示は Waveshare LCD（OLED廃止・Switch/Relay 共通）。 Connectivity = local labels on pin tips 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
I²C レベルシフタ（2026-09-08）: Pico 側 3V3 バス I2C_SDA/SCL（プルアップは MeasureControl の R1653/R1654 4.7k）↔ PT2314E 側 9V バス I2C_SDA_9V/SCL_9V（R412/R413 10k → VCC_TONE）。BSS138 ゲート=3V3。同時に U402 pin25 DGND をチップの足元で A_GND へ（旧 D_GND）。片方だけでは成立しない（DECISIONS「DGND はチップの足元で A_GND へ」）。
OutputStage — label-wired DEST + volume (Q2-A) AMP_SEL → SW101/102 SP3T → RV101/102 A50k Dual → PHONE/LINE MUTE throws = MUTE_NC_*. Sense pole on ControlPanel SW2. Connectivity = local labels on pin tips (grid-snapped).
