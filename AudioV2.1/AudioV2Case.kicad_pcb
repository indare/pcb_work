# Repository indare/pcb_work (continued)

## KiCad design AudioV2.1/AudioV2Case.kicad_pcb (continued)

Parts:
A1601: ADC1804_F_MODULE; ADC1804_F_KYOHRITSU_56x33mm
A1602: Pico2; RaspberryPi_Pico_Common_THT
C1601, C1608, C1623: 10nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C1602, C1613, C1626, C1628: 10uF 25V NP; C_Radial_D5.0mm_H7.0mm_P2.00mm
C1603: 10uF 10V X7R; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C1604, C1605, C1607, C1612, C1614, C1615, C1617, C1618, C1622, C1624, C1625, C1634, C1636, C1637, C1638, C1639, C1641, C1642, C1643, C1646, C1647: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C1606, C1619: 10uF 50V X7R; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C1609, C1620, C1627, C1632: 1.8nF C0G; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C1610: 47uF 35V; CP_Radial_D8.0mm_P3.50mm
C1611: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C1616: 10uF 16V X7R; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C1621: 47uF; CP_Radial_D8.0mm_P3.50mm
C1635, C1640: 10uF 50V; CP_Radial_D5.0mm_P2.00mm
C1645: 10uF 50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1601: RB160M-30; D_SOD-123
F1601: T1A slow 5x20; Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Op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
F1602: PPTC 0.5A hold; PPTC_Radial_D7.9mm_T3.1mm_P5.08mm
J1601: AUDIO; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J1602: V_IN; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J1603: 15_V_IN; TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizont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
NT1601: A_GND-ADC_GND; NetTie-2_SMD_Pad2.0mm
NT1602: ADC_GND_IN-D_GND; NetTie-2_SMD_Pad2.0mm
NT1603: A_GND-D_GND; NetTie-2_SMD_Pad0.5mm
R1601, R1606, R1612, R1615: 4.7k 0.1%; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1602, R1608, R1613, R1617: 47; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1603, R1609, R1614, R1618: 6.19k 0.1%; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1604: 33; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1607, R1610, R1616, R1619: 1k 0.1%; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1611, R1657: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1653, R1654: 4.7k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1659, R1660: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
TP1601: ADC_MCLK; TestPoint_Pad_D1.5mm
U1601, U1602, U1608, U1611: OPA1656; SOIC-8_3.9x4.9mm_P1.27mm
U1603: LT1763-3.3; SOIC-8_3.9x4.9mm_P1.27mm
U1605: TPS3307-33; SOIC-8_3.9x4.9mm_P1.27mm
U1606: LT1763-5; SOIC-8_3.9x4.9mm_P1.27mm
U1607: BP5293-50; BP5293-50_ROHM_SIP-3
Y1601: ASFL1-12.288MHZ-EC-T; Oscillator_SMD_Abracon_ASFL-4Pin_5.0x3.2mm_HandSoldering

Connections:
/3V3: A1602.30 (RUN), A1602.35 (ADC_VREF), A1602.36 (3V3), R1653.1, R1654.1; also elsewhere on the board
/+5V_D: C1621.1, C1622.1, D1601.2 (A), U1607.3 (VOUT); also elsewhere on the board
/+15V: C1605.1, C1606.1, C1618.1, C1619.1, C1634.1, C1635.1, C1636.1, C1637.1, C1638.1, C1646.1, J1603.1, U1601.8 (V+), U1602.8 (V+), U1603.5 (SHDN), U1603.8 (IN), U1606.8 (IN), U1608.8 (V+), U1611.8 (V+); also elsewhere on the board
/-15V: C1639.2, C1640.2, C1641.2, C1642.2, C1643.2, C1647.2, J1603.3, U1601.4 (V-), U1602.4 (V-), U1608.4 (V-), U1611.4 (V-); also elsewhere on the board
/AMP_SEL_L: J1601.2, R1659.1, U1611.3 (INA+); also elsewhere on the board
/AMP_SEL_R: J1601.1, R1660.1, U1611.5 (INB+); also elsewhere on the board
/A_GND: C1634.2, C1635.2, C1636.2, C1637.2, C1638.2, C1639.1, C1640.1, C1641.1, C1642.1, C1643.1, C1646.2, C1647.1, J1603.2, NT1601.2, NT1603.1, R1659.2, R1660.2, U1602.3 (INA+), U1602.5 (INB+); also elsewhere on the board
/D_GND: A1602.3 (GND), A1602.8 (GND), A1602.13 (GND), A1602.18 (GND), A1602.23 (GND), A1602.28 (GND), A1602.38 (GND), C1621.2, C1622.2, C1645.2, NT1602.2, NT1603.2, R1657.2, U1607.2 (GND); also elsewhere on the board
/ENC_INTA: A1602.21 (GPIO16); also elsewhere on the board
/ENC_INTB: A1602.22 (GPIO17); also elsewhere on the board
/I2C_SCL: A1602.27 (GPIO21), R1654.2; also elsewhere on the board
/I2C_SDA: A1602.26 (GPIO20), R1653.2; also elsewhere on the board
/LCD_CS: A1602.7 (GPIO5); also elsewhere on the board
/LCD_DC: A1602.9 (GPIO6); also elsewhere on the board
/LCD_EN: A1602.11 (GPIO8); also elsewhere on the board
/LCD_MOSI: A1602.25 (GPIO19); also elsewhere on the board
/LCD_RST: A1602.10 (GPIO7); also elsewhere on the board
/LCD_SCK: A1602.24 (GPIO18); also elsewhere on the board
/MeasureControl/+3V3_A: A1601.13 (+3V3), C1601.2, C1603.1, C1604.1, C1614.1, C1625.2, R1611.1, U1603.1 (OUT), U1603.2 (SENSE), U1605.2 (SENSE2), U1605.3 (SENSE3), U1605.8 (VDD), U1606.5 (SHDN), Y1601.1 (ST), Y1601.4 (VDD)
/MeasureControl/+5V_A: A1601.12 (+5V), C1616.1, C1617.1, C1624.1, U1605.1 (SENSE1), U1606.1 (OUT), U1606.2 (SENSE)
/MeasureControl/ADC_BCK: A1601.9 (BCK), A1602.2 (GPIO1)
/MeasureControl/ADC_BUF_L: C1628.2, R1612.2, U1611.1 (OUTA), U1611.2 (INA-)
/MeasureControl/ADC_BUF_R: C1613.2, R1601.2, U1611.6 (INB-), U1611.7 (OUTB)
/MeasureControl/ADC_DATA: A1601.10 (DATA), A1602.1 (GPIO0)
/MeasureControl/ADC_GND: A1601.14 (GND), C1601.1, C1603.2, C1604.2, C1605.2, C1606.2, C1607.1, C1608.2, C1614.2, C1615.1, C1616.2, C1617.2, C1618.2, C1619.2, C1623.2, C1624.2, C1625.1, NT1601.1, U1603.3 (GND), U1603.6 (GND), U1603.7 (GND), U1605.4 (GND), U1606.3 (GND), U1606.6 (GND), U1606.7 (GND), Y1601.2 (GND)
/MeasureControl/ADC_LRCK: A1601.8 (LRCK), A1602.4 (GPIO2)
/MeasureControl/ADC_MCLK: A1601.7 (SCKI), R1604.2, TP1601.1 (1_1)
/MeasureControl/ADC_nMR: A1602.20 (GPIO15), U1605.7 (~MR)
/MeasureControl/ADC_nRST: A1601.11 (RST), R1611.2, U1605.5 (~RESET)
/MeasureControl/DEST_ADC: A1602.31 (GPIO26_ADC0), R1657.1
/MeasureControl/PD_12V_MEAS: C1645.1, F1602.2, U1607.1 (VIN)
/MeasureControl/VCOML: A1601.2 (VCOML), C1607.2, U1608.3 (INA+), U1608.5 (INB+)
/MeasureControl/VCOMR: A1601.5 (VCOMR), C1615.2, U1601.3 (INA+), U1601.5 (INB+)
/MeasureControl/VINL+: A1601.1 (VINL+), R1617.1
/MeasureControl/VINL-: A1601.3 (VINL-), R1613.1
/MeasureControl/VINR+: A1601.6 (VINR+), R1608.1
/MeasureControl/VINR-: A1601.4 (VINR-), R1602.1
/PD_12V_SW: C1610.1, C1611.1, C1612.1, F1601.2, F1602.1; also elsewhere on the board
/PD_GND: C1610.2, C1611.2, C1612.2, J1602.1, NT1602.1; also elsewhere on the board
/TP_INT: A1602.16 (GPIO12); also elsewhere on the board
/TP_RST: A1602.17 (GPIO13); also elsewhere on the board
/TP_SCL: A1602.15 (GPIO11); also elsewhere on the board
/TP_SDA: A1602.14 (GPIO10); also elsewhere on the board
unnamed: A1602.39 (VSYS), D1601.1 (K)
unnamed: C1602.1, R1603.2
unnamed: C1613.1, R1609.2
unnamed: C1626.1, R1614.2
unnamed: C1628.1, R1618.2
unnamed: F1601.1, J1602.2
unnamed: C1609.2, R1603.1, R1607.2, U1601.2 (INA-)
unnamed: C1609.1, R1602.2, R1607.1, U1601.1 (OUTA)
unnamed: C1620.2, R1609.1, R1610.2, U1601.6 (INB-)
unnamed: C1620.1, R1608.2, R1610.1, U1601.7 (OUTB)
unnamed: R1601.1, R1606.2, U1602.2 (INA-)
unnamed: C1602.2, R1606.1, U1602.1 (OUTA)
unnamed: R1612.1, R1615.2, U1602.6 (INB-)
unnamed: C1626.2, R1615.1, U1602.7 (OUTB)
unnamed: C1608.1, U1603.4 (BYP)
unnamed: C1623.1, U1606.4 (BYP)
unnamed: C1627.2, R1614.1, R1616.2, U1608.2 (INA-)
unnamed: C1627.1, R1613.2, R1616.1, U1608.1 (OUTA)
unnamed: C1632.2, R1618.1, R1619.2, U1608.6 (INB-)
unnamed: C1632.1, R1617.2, R1619.1, U1608.7 (OUTB)
unnamed: R1604.1, Y1601.3 (OUT)

Notes on the sheet:
ADC1804_F には PCM1804 のデカップリングとジャンパが内蔵済み。本シートは外部コネクタのみをモデル化。
ADC1804_F モジュール / デジタル・インターフェース
PWRWIRE_V2
電源系（2026-09-07 U1604 削除後） PD_12V_SW ─F1602─ PD_12V_MEAS ─ U1607 BP5293-50 → +5V_D（Pico/LCD。GND=D_GND、CIN=C1645） +15V ─────────────────────── U1603 LT1763-3.3 → +3V3_A（ADC。GND=ADC_GND） +15V ─────────────────────── U1606 LT1763-5 → +5V_A （ADC。SHDN=+3V3_A で 3V3 先行） 旧 U1604（MBC2596 12V→6.6V 非絶縁バック）と F1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
POWER/DIGITAL（2026-09-07）: +15V → U1603(+3V3_A) と U1606(+5V_A, SHDN=+3V3_A)。旧 U1604(MBC2596) は削除。U1607=+5V_D（PD_12V_MEAS から）。D1601 ショットキ: +5V_D → Pico VSYS（USB 逆流止め）。Y1601 12.288MHz → R1604 33Ω → SCKI。U1609 XC8107 → LCD_VCC。U1605 TPS3307 監視。
GP9: 旧 MCLK_SENSE（R1605 1k 経由）は 2026-09-07 に削除。ファームは GP9 を読んでいなかった。SCKI の生死は BCK（=SCKI/4）で分かる。GP9 は no_connect。
A3 Pico2 横置き: 南列 1-20 西→東 / 北列 21-40 東→西。VSYS=+5V_D via D1601 ショットキ, GND=D_GND | GP0=ADC_DATA GP1=ADC_BCK GP2=ADC_LRCK | GP3/GP4=NC(旧 LCD SPI) | GP5=LCD_CS GP6=LCD_DC GP7=LCD_RST GP8=LCD_EN | GP9=NC（旧 MCLK_SENSE、2026-09-07 削除） | GP10=TP_SDA GP11=TP_SCL GP12=TP_INT GP13=TP_RST | GP15=ADC_nMR (TPS330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
LRCK/BCK の向きは ADC マスタモード想定。スレーブ時は階層ピンの方向を合わせて変更すること。
OPA1656 の各電源ペアに 100nF を配置。バルクコンデンサはアナログフロントエンドの電源入口付近に。
U1606 EN=+3V3_A (3V3-first). AbsMax VCC-VDD protection.
PATCH_V1
GND: NT1601=A_GND─ADC_GND（A1601 近傍・アナログ星点）。NT1602=PD_GND─D_GND（PD 入口）。NT1603=A_GND─D_GND（2026-09-07 新設。U1604 削除で失われた A_GND↔D_GND の橋を明示化）。⚠ NT1601 / NT1602 / NT1603 は PCB で近接させる（1点アース。I2S の帰り・U403 の帰路・U201 の Ciso 経由 CM が全部ここを通る）。Pico/LCD は D_GND のみ。D_GND は太く短く、アナログ入力から離す。
U1605=TPS3307-33D SO-8: SENSE1=+5V_A (4.55V) SENSE2=+3V3_A (2.93V) SENSE3=VDD; VDD=+3V3_A C1614 100nF; ~RESET PP -> ADC_nRST + R1611; GP15 OD -> ~MR (do not drive H); RESET pin NC; 200ms delay. Replaces TPS3808G33/G50 SOT-23-6.
チャンネルあたりの公式リファレンス構成: 入力インバータ + ADC VCOM 基準の反転 LPF ドライバ×2。
OPA2134 からの OPA1656 置き換え。6.19k/4.7k 網（前段入力抵抗は 2026-09-07 に 3.3k→6.19k）では FET 入力が有利。試作で安定性とフルスケール・レベルを確認すること。
左チャンネル
PATCH_V2
JP1F: ショート=H / 開放=L。本設計は S/M=L, OSR2=L OSR1=H OSR0=H（ADCマスタ 48k/256fs）、24bit I²S → FMT1=L（開放）FMT0=H（ショート）。HPF はモジュールマニュアルに従う。
U1603 LT1763-3.3 (+3V3_A). Fixed LDO; SHDN tied for always-on or as designed. Local CIN/COUT.
FE_PATCH_V1
電源: USB VBUS → Pico 内部ショットキ → VSYS。D1601 が +5V_D への逆流を止めるので、USB だけ挿すと Pico は動き LCD は消える。VBUS(pin40) は NC。
U1609 XC8107AC20MR-G ロードスイッチ: LCD_EN High=ON / Low・Hi-Z=OFF（Active High, VCEH 1.5V min → Pico 3.3V で直接駆動可）。R1620 100k=CE プルダウンで起動時 OFF。初号は常時 ON 可。OFF 運用時は SPI/タッチを Low/Hi-Z に。ソフトスタート 0.6ms typ・短絡/逆流/過熱/UVLO 保護内蔵。C1633=CIN, C1631=CL は各 10uF/3216 を IC 直近へ。FLG は未使用（NC）。
GP15=ADC_nMR は TPS3307 の ~MR。オープンドレインのみ、H は駆動しない。 ~RESET はプッシュプルなので ADC_nRST には直接ワイヤ AND しない。
階層ポート / 右チャンネル

Parts:
C311, C312, C313, C314: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C315, C316, C317, C318: 1uF 50V X7R; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C_BULK_N301: 100uF 35V; CP_Elec_10x12.6
C_BULK_P301: 100uF 35V; CP_Elec_10x12.6
C_IO301: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
H301, H302, H303, H304: M3; MountingHole_3.2mm_M3
J_ANA301: SLOT ANA (D18); PinHeader_2x05_P2.54mm_Vertical
J_PWR301: SLOT PWR/CTRL (D18); PinHeader_2x08_P2.54mm_Vertical
S_ADDR_A0: ADDR A0; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm_NumberLabels
S_ADDR_A1: ADDR A1; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm_NumberLabels
S_ADDR_A2: ADDR A2; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm_NumberLabels
U311, U312: TMUX7612; TSSOP-16_4.4x5mm_P0.65mm
U_IO301: MCP23017; DIP-28_W7.62mm

Connections:
/3V3: C_IO301.1, J_PWR301.10, S_ADDR_A0.3 (B), S_ADDR_A1.3 (B), S_ADDR_A2.3 (B), U_IO301.9 (V_{DD}), U_IO301.18 (~RESET); also elsewhere on the board
/+15V: C311.1, C313.1, C315.1, C317.1, C_BULK_P301.1, J_PWR301.1, U311.13 (VDD), U312.13 (VDD); also elsewhere on the board
/-15V: C312.2, C314.2, C316.2, C318.2, C_BULK_N301.2, J_PWR301.3, U311.4 (VSS), U312.4 (VSS); also elsewhere on the board
/AMP_SEL_L: J_ANA301.7, U311.7 (D4), U311.10 (D3), U312.7 (D4), U312.10 (D3); also elsewhere on the board
/AMP_SEL_R: J_ANA301.10, U311.2 (D1), U311.15 (D2), U312.2 (D1), U312.15 (D2); also elsewhere on the board
/A_GND: C311.2, C312.1, C313.2, C314.1, C315.2, C316.1, C317.2, C318.1, C_BULK_N301.1, C_BULK_P301.2, J_ANA301.1, J_ANA301.2, J_ANA301.4, J_ANA301.5, J_ANA301.8, J_ANA301.9, J_PWR301.2, J_PWR301.4, U311.5 (GND), U312.5 (GND); also elsewhere on the board
/AmpBankSwitch/+5V_COIL: J_PWR301.5
/AmpBankSwitch/ADDR_A0: S_ADDR_A0.2 (C), U_IO301.15 (A0)
/AmpBankSwitch/ADDR_A1: S_ADDR_A1.2 (C), U_IO301.16 (A1)
/AmpBankSwitch/ADDR_A2: S_ADDR_A2.2 (C), U_IO301.17 (A2)
/AmpBankSwitch/CH1_OUT_L: U311.6 (S4); also elsewhere on the board
/AmpBankSwitch/CH1_OUT_R: U311.3 (S1); also elsewhere on the board
/AmpBankSwitch/CH2_OUT_L: U311.11 (S3); also elsewhere on the board
/AmpBankSwitch/CH2_OUT_R: U311.14 (S2); also elsewhere on the board
/AmpBankSwitch/CH3_OUT_L: U312.6 (S4); also elsewhere on the board
/AmpBankSwitch/CH3_OUT_R: U312.3 (S1); also elsewhere on the board
/AmpBankSwitch/CH4_OUT_L: U312.11 (S3); also elsewhere on the board
/AmpBankSwitch/CH4_OUT_R: U312.14 (S2); also elsewhere on the board
/AmpBankSwitch/GND_COIL: J_PWR301.6
/AmpBankSwitch/SEL_CH1: U311.1 (SEL1), U311.8 (SEL4), U_IO301.1 (GPB0)
/AmpBankSwitch/SEL_CH2: U311.9 (SEL3), U311.16 (SEL2), U_IO301.2 (GPB1)
/AmpBankSwitch/SEL_CH3: U312.1 (SEL1), U312.8 (SEL4), U_IO301.3 (GPB2)
/AmpBankSwitch/SEL_CH4: U312.9 (SEL3), U312.16 (SEL2), U_IO301.4 (GPB3)
/D_GND: C_IO301.2, J_PWR301.8, S_ADDR_A0.1 (A), S_ADDR_A1.1 (A), S_ADDR_A2.1 (A), U_IO301.10 (V_{SS}); also elsewhere on the board
/I2C_SCL: J_PWR301.9, U_IO301.12 (SCK); also elsewhere on the board
/I2C_SDA: J_PWR301.7, U_IO301.13 (SDA); also elsewhere on the board
/TONE_L: J_ANA301.3; also elsewhere on the board
/TONE_R: J_ANA301.6; also elsewhere on the board

Notes on the sheet:
I2C ADDR jumpers (skip UI 0x22): tier1 000→0x20 tier2 001→0x21 tier3 011→0x23 tier4 100→0x24 tier5 101→0x25 tier6 110→0x26 (A2 A1 A0; Bridged12=GND=0, bridge 2-3 for 1)
