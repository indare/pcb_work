# Repository indare/pcb_work (continued)

## KiCad design AudioV2.1/AudioV2Case.kicad_pcb (continued)

Parts:
C321: 100uF 25V; CP_Elec_10x12.6
C322: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C_BULK_N302: 100uF 35V; CP_Elec_10x12.6
C_BULK_P302: 100uF 35V; CP_Elec_10x12.6
C_IO302: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
H311, H312, H313, H314: M3; MountingHole_3.2mm_M3
J_ANA302: SLOT ANA (D18); PinHeader_2x05_P2.54mm_Vertical
J_PWR302: SLOT PWR/CTRL (D18); PinHeader_2x08_P2.54mm_Vertical
K301, K302, K303, K304: AZ850P2-5; Relay_DPDT_FRT5
R_ADDR_A0: ADDR A0; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm_NumberLabels
R_ADDR_A1: ADDR A1; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm_NumberLabels
R_ADDR_A2: ADDR A2; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm_NumberLabels
U321: TBD62083APG; DIP-18_W7.62mm
U_IO302: MCP23017; DIP-28_W7.62mm

Connections:
/3V3: C_IO302.1, J_PWR302.10, R_ADDR_A0.3 (B), R_ADDR_A1.3 (B), R_ADDR_A2.3 (B), U_IO302.9 (V_{DD}), U_IO302.18 (~RESET); also elsewhere on the board
/+5V_COIL: C321.1, C322.1, J_PWR302.5, K301.1, K301.10, K302.1, K302.10, K303.1, K303.10, K304.1, K304.10, U321.10 (COM); also elsewhere on the board
/+15V: C_BULK_P302.1, J_PWR302.1; also elsewhere on the board
/-15V: C_BULK_N302.2, J_PWR302.3; also elsewhere on the board
/AMP_SEL_L: J_ANA302.7, K301.7, K302.7, K303.7, K304.7; also elsewhere on the board
/AMP_SEL_R: J_ANA302.10, K301.4, K302.4, K303.4, K304.4; also elsewhere on the board
/A_GND: C_BULK_N302.1, C_BULK_P302.2, J_ANA302.1, J_ANA302.2, J_ANA302.4, J_ANA302.5, J_ANA302.8, J_ANA302.9, J_PWR302.2, J_PWR302.4; also elsewhere on the board
/AmpBankRelay/ADDR_A0: R_ADDR_A0.2 (C), U_IO302.15 (A0)
/AmpBankRelay/ADDR_A1: R_ADDR_A1.2 (C), U_IO302.16 (A1)
/AmpBankRelay/ADDR_A2: R_ADDR_A2.2 (C), U_IO302.17 (A2)
/AmpBankRelay/CH1_OUT_L: K301.8; also elsewhere on the board
/AmpBankRelay/CH1_OUT_R: K301.3; also elsewhere on the board
/AmpBankRelay/CH1_RST: U321.2 (I2), U_IO302.27 (GPA6)
/AmpBankRelay/CH1_RSTC: K301.6, U321.17 (O2)
/AmpBankRelay/CH1_SET: U321.1 (I1), U_IO302.28 (GPA7)
/AmpBankRelay/CH1_SETC: K301.5, U321.18 (O1)
/AmpBankRelay/CH2_OUT_L: K302.8; also elsewhere on the board
/AmpBankRelay/CH2_OUT_R: K302.3; also elsewhere on the board
/AmpBankRelay/CH2_RST: U321.4 (I4), U_IO302.25 (GPA4)
/AmpBankRelay/CH2_RSTC: K302.6, U321.15 (O4)
/AmpBankRelay/CH2_SET: U321.3 (I3), U_IO302.26 (GPA5)
/AmpBankRelay/CH2_SETC: K302.5, U321.16 (O3)
/AmpBankRelay/CH3_OUT_L: K303.8; also elsewhere on the board
/AmpBankRelay/CH3_OUT_R: K303.3; also elsewhere on the board
/AmpBankRelay/CH3_RST: U321.6 (I6), U_IO302.23 (GPA2)
/AmpBankRelay/CH3_RSTC: K303.6, U321.13 (O6)
/AmpBankRelay/CH3_SET: U321.5 (I5), U_IO302.24 (GPA3)
/AmpBankRelay/CH3_SETC: K303.5, U321.14 (O5)
/AmpBankRelay/CH4_OUT_L: K304.8; also elsewhere on the board
/AmpBankRelay/CH4_OUT_R: K304.3; also elsewhere on the board
/AmpBankRelay/CH4_RST: U321.8 (I8), U_IO302.21 (GPA0)
/AmpBankRelay/CH4_RSTC: K304.6, U321.11 (O8)
/AmpBankRelay/CH4_SET: U321.7 (I7), U_IO302.22 (GPA1)
/AmpBankRelay/CH4_SETC: K304.5, U321.12 (O7)
/D_GND: C_IO302.2, J_PWR302.8, R_ADDR_A0.1 (A), R_ADDR_A1.1 (A), R_ADDR_A2.1 (A), U_IO302.10 (V_{SS}); also elsewhere on the board
/GND_COIL: C321.2, C322.2, J_PWR302.6, U321.9 (GND); also elsewhere on the board
/I2C_SCL: J_PWR302.9, U_IO302.12 (SCK); also elsewhere on the board
/I2C_SDA: J_PWR302.7, U_IO302.13 (SDA); also elsewhere on the board
/TONE_L: J_ANA302.3; also elsewhere on the board
/TONE_R: J_ANA302.6; also elsewhere on the board

Notes on the sheet:
I2C ADDR jumpers (skip UI 0x22): tier1 000→0x20 tier2 001→0x21 tier3 011→0x23 tier4 100→0x24 tier5 101→0x25 tier6 110→0x26 (A2 A1 A0; Bridged12=GND=0, bridge 2-3 for 1)

Parts:
C1629, C1650: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C1630: 22uF; CP_Radial_D6.3mm_P2.50mm
C1631, C1633: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D403: 12V panel LED; LED_D5.0mm
D1610: DEST 1; LED_D5.0mm
D1611: DEST 2; LED_D5.0mm
ENC1601: ENC_CH; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
ENC1602: ENC_BASS; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
ENC1603: ENC_TREBLE; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
J_LCD1601: LCD cable A (XH8); JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J_LCD1602: LCD cable B (XH8); JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J_PNL1602_1: FrontPanel digital A (odd); JST_XH_B10B-XH-A_1x10_P2.50mm_Vertical
J_PNL1602_2: FrontPanel digital B (even); JST_XH_B10B-XH-A_1x10_P2.50mm_Vertical
J_PNL_A1602_1: FrontPanel analog A (odd); JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J_PNL_A1602_2: LCD cable A (XH8); JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J_PNL_P1611: FrontPanel 12V raw; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J_PNL_P1612: FrontPanel 12V switched; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R401, R1651, R1652: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1620: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1661, R1662: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
RV501: A50k Dual HP; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
RV502: A50k Dual LINE; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
SW402: Cosland 2MS1 PWR; SW_Toggle_Cosland_2MS1_VS2_SPDT
SW501: Cosland 2MD1 DEST; SW_Toggle_Cosland_2MD1_VS2_DPDT
U1609: XC8107AC20MR-G; SOT-23-5_HandSoldering
U1610: MCP23017 (UI 0x22); DIP-28_W7.62mm

Connections:
/3V3: C1650.1, J_PNL1602_1.1, R1651.1, R1652.1, R1661.1, R1662.1, U1610.9 (V_{DD}), U1610.16 (A1), U1610.18 (~RESET); also elsewhere on the board
/+5V_D: C1633.1, J_PNL1602_2.1, U1609.5 (VIN); also elsewhere on the board
/AMP_SEL_L: J_PNL_A1602_1.1, SW501.2 (B); also elsewhere on the board
/AMP_SEL_R: J_PNL_A1602_2.1, SW501.5 (B); also elsewhere on the board
/A_GND: J_PNL_A1602_1.4, J_PNL_A1602_2.4, RV501.3, RV501.6, RV502.3, RV502.6; also elsewhere on the board
/D_GND: C1629.1, C1630.2, C1631.2, C1633.2, C1650.2, ENC1601.C, ENC1601.MP, ENC1601.S2, ENC1602.C, ENC1602.MP, ENC1602.S2, ENC1603.C, ENC1603.MP, ENC1603.S2, J_LCD1601.3, J_PNL1602_1.2, J_PNL1602_2.2, R1620.2, U1609.2 (VSS), U1610.10 (V_{SS}), U1610.15 (A0), U1610.17 (A2); also elsewhere on the board
/ENC_INTA: J_PNL1602_1.4, R1661.2, U1610.20 (INTA); also elsewhere on the board
/ENC_INTB: J_PNL1602_2.4, R1662.2, U1610.19 (INTB); also elsewhere on the board
/FrontPanel/ENC1_A: ENC1601.A, U1610.21 (GPA0)
/FrontPanel/ENC1_B: ENC1601.B, U1610.22 (GPA1)
/FrontPanel/ENC1_SW: ENC1601.S1, U1610.23 (GPA2)
/FrontPanel/ENC2_A: ENC1602.A, U1610.24 (GPA3)
/FrontPanel/ENC2_B: ENC1602.B, U1610.25 (GPA4)
/FrontPanel/ENC2_SW: ENC1602.S1, U1610.26 (GPA5)
/FrontPanel/ENC3_A: ENC1603.A, U1610.27 (GPA6)
/FrontPanel/ENC3_B: ENC1603.B, U1610.28 (GPA7)
/FrontPanel/ENC3_SW: ENC1603.S1, U1610.1 (GPB0)
/FrontPanel/LCD_VCC: C1629.2, C1630.1, C1631.1, J_LCD1601.1, J_LCD1602.3, U1609.1 (VOUT)
/FrontPanel/LED_12V_A: D403.2 (A), R401.2
/FrontPanel/LED_DEST1: D1610.1 (K), U1610.3 (GPB2)
/FrontPanel/LED_DEST1_A: D1610.2 (A), R1651.2
/FrontPanel/LED_DEST2: D1611.1 (K), U1610.2 (GPB1)
/FrontPanel/LED_DEST2_A: D1611.2 (A), R1652.2
/FrontPanel/LINE_PRE_L: RV502.1, SW501.3 (C)
/FrontPanel/LINE_PRE_R: RV502.4, SW501.6 (C)
/FrontPanel/PHONE_PRE_L: RV501.1, SW501.1 (A)
/FrontPanel/PHONE_PRE_R: RV501.4, SW501.4 (A)
/I2C_SCL: J_PNL1602_2.3, U1610.12 (SCK); also elsewhere on the board
/I2C_SDA: J_PNL1602_1.3, U1610.13 (SDA); also elsewhere on the board
/LCD_CS: J_LCD1601.8, J_PNL1602_1.5; also elsewhere on the board
/LCD_DC: J_LCD1602.1, J_PNL1602_2.5; also elsewhere on the board
/LCD_EN: J_PNL1602_2.6, R1620.1, U1609.4 (CE); also elsewhere on the board
/LCD_MOSI: J_LCD1601.5, J_PNL1602_2.7; also elsewhere on the board
/LCD_RST: J_LCD1602.2, J_PNL1602_1.6; also elsewhere on the board
/LCD_SCK: J_LCD1601.6, J_PNL1602_1.7; also elsewhere on the board
/LINE_L: J_PNL_A1602_1.3, RV502.2; also elsewhere on the board
/LINE_R: J_PNL_A1602_2.3, RV502.5; also elsewhere on the board
/PD_12V: J_PNL_P1611.1, SW402.2 (B); also elsewhere on the board
/PD_12V_SW: J_PNL_P1612.1, R401.1, SW402.1 (A); also elsewhere on the board
/PD_GND: D403.1 (K), J_PNL_P1611.2, J_PNL_P1612.2; also elsewhere on the board
/PHONE_BUF_L: J_PNL_A1602_1.2, RV501.2; also elsewhere on the board
/PHONE_BUF_R: J_PNL_A1602_2.2, RV501.5; also elsewhere on the board
/TP_INT: J_LCD1602.6, J_PNL1602_1.9; also elsewhere on the board
/TP_RST: J_LCD1602.7, J_PNL1602_2.9; also elsewhere on the board
/TP_SCL: J_LCD1602.5, J_PNL1602_2.8; also elsewhere on the board
/TP_SDA: J_LCD1602.4, J_PNL1602_1.8; also elsewhere on the board

Notes on the sheet:
UI表示: Waveshare LCD（CH/DEST/Bass/Treble）。操作は ENC×3 / DEST SW / ポットのまま。 2.42 OLED（J_OLED）は廃止。FrontPanel は AmpBankSwitch / AmpBankRelay 共通。

Parts:
AMP601: NE5532 / DIP-8 compatible; DIP-8_W7.62mm_Socket
C601, C604: 2.2uF film; C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C602, C605: 1uF film; C_Rect_L7.2mm_W4.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C608, C609: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
R601, R607: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R602, R608: 47R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R603, R609: 220k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R604, R606, R610, R612: 20k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
/+15V: AMP601.8 (V+), C608.1; also elsewhere on the board
/-15V: AMP601.4 (V-), C609.2; also elsewhere on the board
/A_GND: C608.2, C609.1, R601.1, R603.2, R604.2, R607.2, R609.2, R610.2; also elsewhere on the board
/AmpBankSwitch/CH1_OUT_L: C601.2, R603.1; also elsewhere on the board
/AmpBankSwitch/CH1_OUT_R: C604.1, R609.1; also elsewhere on the board
/TONE_L: C602.1; also elsewhere on the board
/TONE_R: C605.1; also elsewhere on the board
unnamed: AMP601.1, R602.1, R606.1
unnamed: AMP601.7, R608.2, R612.2
unnamed: AMP601.3 (+), C602.2, R601.2
unnamed: AMP601.2 (-), R604.1, R606.2
unnamed: AMP601.5 (+), C605.2, R607.1
unnamed: AMP601.6 (-), R610.1, R612.1
unnamed: C601.1, R602.2
unnamed: C604.2, R608.1

Parts of its further copies:
AMP701, AMP801, AMP901, AMP1001, AMP1101, AMP1201, AMP1301: NE5532 / DIP-8 compatible; DIP-8_W7.62mm_Socket
C701, C704, C801, C804, C901, C904, C1001, C1004, C1101, C1104, C1201, C1204, C1301, C1304: 2.2uF film; C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C702, C705, C802, C805, C902, C905, C1002, C1005, C1102, C1105, C1202, C1205, C1302, C1305: 1uF film; C_Rect_L7.2mm_W4.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C708, C709, C808, C809, C908, C909, C1008, C1009, C1108, C1109, C1208, C1209, C1308, C1309: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
R701, R707, R801, R807, R901, R907, R1001, R1007, R1101, R1107, R1201, R1207, R1301, R1307: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R702, R708, R802, R808, R902, R908, R1002, R1008, R1102, R1108, R1202, R1208, R1302, R1308: 47R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R703, R709, R803, R809, R903, R909, R1003, R1009, R1103, R1109, R1203, R1209, R1303, R1309: 220k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Connections of its further copies:
/+15V: AMP701.8 (V+), AMP801.8 (V+), AMP901.8 (V+), AMP1001.8 (V+), AMP1101.8 (V+), AMP1201.8 (V+), AMP1301.8 (V+), C708.1, C808.1, C908.1, C1008.1, C1108.1, C1208.1, C1308.1; also elsewhere on the board
/-15V: AMP701.4 (V-), AMP801.4 (V-), AMP901.4 (V-), AMP1001.4 (V-), AMP1101.4 (V-), AMP1201.4 (V-), AMP1301.4 (V-), C709.2, C809.2, C909.2, C1009.2, C1109.2, C1209.2, C1309.2; also elsewhere on the board
/A_GND: C708.2, C709.1, C808.2, C809.1, C908.2, C909.1, C1008.2, C1009.1, C1108.2, C1109.1, C1208.2, C1209.1, C1308.2, C1309.1, R701.1, R703.2, R707.2, R709.2, R801.1, R803.2, R807.2, R809.2, R901.1, R903.2, R907.2, R909.2, R1001.1, R1003.2, R1007.2, R1009.2, R1101.1, R1103.2, R1107.2, R1109.2, R1201.1, R1203.2, R1207.2, R1209.2, R1301.1, R1303.2, R1307.2, R1309.2; also elsewhere on the board
/AmpBankRelay/CH1_OUT_L: C1001.2, R1003.1; also elsewhere on the board
/AmpBankRelay/CH1_OUT_R: C1004.1, R1009.1; also elsewhere on the board
/AmpBankRelay/CH2_OUT_L: C1101.2, R1103.1; also elsewhere on the board
/AmpBankRelay/CH2_OUT_R: C1104.1, R1109.1; also elsewhere on the board
/AmpBankRelay/CH3_OUT_L: C1201.2, R1203.1; also elsewhere on the board
/AmpBankRelay/CH3_OUT_R: C1204.1, R1209.1; also elsewhere on the board
/AmpBankRelay/CH4_OUT_L: C1301.2, R1303.1; also elsewhere on the board
/AmpBankRelay/CH4_OUT_R: C1304.1, R1309.1; also elsewhere on the board
/AmpBankSwitch/CH2_OUT_L: C701.2, R703.1; also elsewhere on the board
/AmpBankSwitch/CH2_OUT_R: C704.1, R709.1; also elsewhere on the board
/AmpBankSwitch/CH3_OUT_L: C801.2, R803.1; also elsewhere on the board
/AmpBankSwitch/CH3_OUT_R: C804.1, R809.1; also elsewhere on the board
/AmpBankSwitch/CH4_OUT_L: C901.2, R903.1; also elsewhere on the board
/AmpBankSwitch/CH4_OUT_R: C904.1, R909.1; also elsewhere on the board
/TONE_L: C702.1, C802.1, C902.1, C1002.1, C1102.1, C1202.1, C1302.1; also elsewhere on the board
/TONE_R: C705.1, C805.1, C905.1, C1005.1, C1105.1, C1205.1, C1305.1; also elsewhere on the board
unnamed 147: AMP701.1, R702.1; also elsewhere on the board
unnamed 148: AMP701.7, R708.2; also elsewhere on the board
unnamed: AMP701.3 (+), C702.2, R701.2
unnamed 150: AMP701.2 (-); also elsewhere on the board
unnamed: AMP701.5 (+), C705.2, R707.1
unnamed 152: AMP701.6 (-); also elsewhere on the board
unnamed 153: AMP801.1, R802.1; also elsewhere on the board
unnamed 154: AMP801.7, R808.2; also elsewhere on the board
unnamed: AMP801.3 (+), C802.2, R801.2
unnamed 156: AMP801.2 (-); also elsewhere on the board
unnamed: AMP801.5 (+), C805.2, R807.1
unnamed 158: AMP801.6 (-); also elsewhere on the board
unnamed 159: AMP901.1, R902.1; also elsewhere on the board
unnamed 160: AMP901.7, R908.2; also elsewhere on the board
unnamed: AMP901.3 (+), C902.2, R901.2
unnamed 162: AMP901.2 (-); also elsewhere on the board
unnamed: AMP901.5 (+), C905.2, R907.1
unnamed 164: AMP901.6 (-); also elsewhere on the board
unnamed 165: AMP1001.1, R1002.1; also elsewhere on the board
unnamed 166: AMP1001.7, R1008.2; also elsewhere on the board
unnamed: AMP1001.3 (+), C1002.2, R1001.2
unnamed 168: AMP1001.2 (-); also elsewhere on the board
unnamed: AMP1001.5 (+), C1005.2, R1007.1
unnamed 170: AMP1001.6 (-); also elsewhere on the board
unnamed 171: AMP1101.1, R1102.1; also elsewhere on the board
unnamed 172: AMP1101.7, R1108.2; also elsewhere on the board
unnamed: AMP1101.3 (+), C1102.2, R1101.2
unnamed 174: AMP1101.2 (-); also elsewhere on the board
unnamed: AMP1101.5 (+), C1105.2, R1107.1
unnamed 176: AMP1101.6 (-); also elsewhere on the board
unnamed 177: AMP1201.1, R1202.1; also elsewhere on the board
unnamed 178: AMP1201.7, R1208.2; also elsewhere on the board
unnamed: AMP1201.3 (+), C1202.2, R1201.2
unnamed 180: AMP1201.2 (-); also elsewhere on the board
unnamed: AMP1201.5 (+), C1205.2, R1207.1
unnamed 182: AMP1201.6 (-); also elsewhere on the board
unnamed 183: AMP1301.1, R1302.1; also elsewhere on the board
unnamed 184: AMP1301.7, R1308.2; also elsewhere on the board
unnamed: AMP1301.3 (+), C1302.2, R1301.2
unnamed 186: AMP1301.2 (-); also elsewhere on the board
unnamed: AMP1301.5 (+), C1305.2, R1307.1
unnamed 188: AMP1301.6 (-); also elsewhere on the board
unnamed: C701.1, R702.2
unnamed: C704.2, R708.1
unnamed: C801.1, R802.2
unnamed: C804.2, R808.1
unnamed: C901.1, R902.2
unnamed: C904.2, R908.1
unnamed: C1001.1, R1002.2
unnamed: C1004.2, R1008.1
unnamed: C1101.1, R1102.2
unnamed: C1104.2, R1108.1
unnamed: C1201.1, R1202.2
unnamed: C1204.2, R1208.1
unnamed: C1301.1, R1302.2
unnamed: C1304.2, R1308.1

Notes on the sheet:
AmpBank / AmpChannel - one channel, instantiated x10. SW selects this channel's input AND output. Supply is always on. GAIN = 1 + Rf/Rg (default 20k/20k = 2)
